# Keil uVision project SofeHome.uvprojx, settings and files
target SofeHome (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SofeHome +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\ADXL345;..\HARDWARE\DS18B20;..\HARDWARE\DHT11;..\HARDWARE\inc;..\HARDWARE\ADC;..\HARDWARE\HCSR501;..\HARDWARE\BEEP;..\HARDWARE\SIM800\SIM800;..\HARDWARE\SIM800\TIMER;..\HARDWARE\SIM800\USART
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/scr/: control.c mqtt.c timer2.c timer3.c timer4.c usart1.c usart2.c wifi.c stm32f10x_it.c delay.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/HCSR501/: humanBodyInfrar.c
    ../HARDWARE/BEEP/: beep.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_sdio.c stm32f10x_rtc.c stm32f10x_iwdg.c stm32f10x_i2c.c stm32f10x_adc.c
  group README
    ../: README.TXT
  group SIM800
    ../HARDWARE/SIM800/SIM800/: sim800.c
    ../HARDWARE/SIM800/TIMER/: timerSIM.c
    ../HARDWARE/SIM800/USART/: usartSIM.c
